# IAR project lib_aws_polly.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\lib\llhttp\include; ..\..\..\lib\aws-polly-c\src\include; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_hp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: LibPlatform.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group aws_polly
    ../../../lib/aws-polly-c/src/source/: http_parser.c netio.c polly.c sigv4.c
